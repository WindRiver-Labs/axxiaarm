require linux-yocto-axxiaarm.inc

KBRANCH_axxiaarm64 = "v4.18/standard/wr-axxia/base"
KBRANCH_axxiaarm = "v4.18/standard/wr-axxia/base"
