require linux-yocto-axxiaarm.inc

KBRANCH_axxiaarm64 = "standard/axxia/base"
KBRANCH_axxiaarm = "standard/axxia/base"
