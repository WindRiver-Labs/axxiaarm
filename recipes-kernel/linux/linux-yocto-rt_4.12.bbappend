require linux-yocto-axxiaarm.inc

KBRANCH_axxiaarm = "standard/preempt-rt/wr-axxia/base"
KBRANCH_axxiaarm64 = "standard/preempt-rt/wr-axxia/base"
