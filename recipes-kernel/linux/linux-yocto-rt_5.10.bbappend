require linux-yocto-axxiaarm.inc

KBRANCH_axxiaarm = "v5.10/standard/preempt-rt/sdkv5.10/axxia"
KBRANCH_axxiaarm64 = "v5.10/standard/preempt-rt/sdkv5.10/axxia"
