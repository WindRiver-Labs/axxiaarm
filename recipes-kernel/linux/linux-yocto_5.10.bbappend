require linux-yocto-axxiaarm.inc

KBRANCH_axxiaarm64 = "v5.10/standard/sdkv5.10/axxia"
KBRANCH_axxiaarm = "v5.10/standard/sdkv5.10/axxia"
