require linux-windriver-axxiaarm.inc
