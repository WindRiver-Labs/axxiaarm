require linux-yocto-axxiaarm.inc

KBRANCH_axxiaarm = "v4.18/standard/preempt-rt/wr-axxia/base"
KBRANCH_axxiaarm64 = "v4.18/standard/preempt-rt/wr-axxia/base"
